IMAGE_INSTALL:append += " qca-nss-userspace-oss"
